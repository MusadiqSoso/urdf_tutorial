Commit message: Update 01-myfirst.urdf

File: urdf/01-myfirst.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: geometry visual rectangle length=8 width=8
